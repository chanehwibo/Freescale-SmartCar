# Keil uVision project mk60_lib_test.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MK60DN512xxx10 Freescale
  pack: Keil.Kinetis_K60_DFP.1.5.1
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: mk60_lib_test
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\USER;..\MK60Dxx10_Lib\inc;..\MK60Dxx10_Lib\src;..\MK60Dxx10_Lib\core;..\APP\control;..\APP\OV7725;..\APP\IIC;..\APP\OLED;..\APP\servo_pd;..\APP\motor_pid
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  group CORE
    ../MK60Dxx10_Lib/core/: startup_MK60D10.s
  group USER
    ./: main.c Readme.txt
  group APP
    ../APP/IIC/: iic.c
    ../APP/OV7725/: ov7725.c
    ../APP/OLED/: oled.c
    ../APP/control/: control.c
    ../APP/servo_pd/: servo_pd.c
    ../APP/motor_pid/: motor_pid.c
  group MK60Dxx10_Lib
    ../MK60Dxx10_Lib/src/: mk60_ftm.c mk60_gpio.c mk60_lptmr.c mk60_pit.c mk60_sdhc.c mk60_spi.c mk60_sys.c mk60_uart.c mk60_adc.c k60_dma.c
